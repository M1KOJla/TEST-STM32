# IAR project 1-Test.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F103CB ST STM32F103CB
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCIncludePath2: CMSIS\; Src; Inc
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: 1-Test.hex
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkIcfFile: CMSIS\stm32f103xb_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group (top)
    ./: main.c
  group CMSIS
    CMSIS/: cmsis_compiler.h cmsis_iccarm.h cmsis_version.h core_cm3.h startup_stm32f103xb.s stm32f103xb.h stm32f1xx.h system_stm32f1xx.c system_stm32f1xx.h
  group Inc
    Inc/: button_init.h button_proc.h led_init.h led_proc.h uart_init.h uart_proc.h
  group Src
    Src/: button_init.c button_proc.c led_init.c led_proc.c uart_init.c uart_proc.c
